# Keil uVision project matrix_2.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: matrix_2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ./User;./lib;..\led_matrix_1\Lib;..\..\1106\Calculator\lib;.\interrupt
  group STARTUP
    ./: STARTUP.A51
  group USER
    ./USER/: main.c
    ./user/: system.c system.h
  group MATRIX
    ../led_matrix_1/src/: matrix.c
  group KEYBOARD
    ../../1106/Calculator/src/: keyboard.c
  group SNAKE
    ./src/: snake.c
    ./lib/: snake.h
  group INTERRUPT
    ./interrupt/: inter.c inter.h
