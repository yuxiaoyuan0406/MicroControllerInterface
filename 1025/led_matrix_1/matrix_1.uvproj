# Keil uVision project matrix_1.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: matrix_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User;.\Lib
  asm include: .\Startup
  group STARTUP
    ./Startup/: STARTUP.A51
  group USER
    ./User/: main.c main.h
  group SYSTEM
    ./User/: system.c system.h
  group KEYBOARD
    ./lib/: keyboard.h
    ./src/: keyboard.c
  group LED_MATRIX
    ./lib/: figure.h matrix.h
    ./src/: matrix.c
