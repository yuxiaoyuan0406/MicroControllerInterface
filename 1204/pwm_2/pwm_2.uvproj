# Keil uVision project pwm_2.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: pwm_2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\pwm;.\USER;.\INTER
  group STARTUP
    ./: STARTUP.A51
  group USER
    ./USER/: main.c
  group SYSTEM
    ./USER/: system.h
    ./user/: system.c
  group PWM
    ./pwm/: pwm.c pwm.h
  group INTERRUPT
    ./INTER/: interrupt.c
    ./inter/: interrupt.h
  group README
    ./: README.md
target PWM_2 (MCS-51)
  device: STC89C52RC STC
  cpu: as above
  output: pwm_2 +hex
  c flags: Optimize=8 SizeSpeed=1
