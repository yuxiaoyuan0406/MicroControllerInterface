# Keil uVision project pwm_1.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: pwm_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Pwm;.\System;.\User
  group STARTUP
    ./: STARTUP.A51
  group SYSTEM
    ./system/: system.c system.h
  group USER
    ./user/: main.c
  group PWM
    ./pwm/: pwm.h pwm.c
