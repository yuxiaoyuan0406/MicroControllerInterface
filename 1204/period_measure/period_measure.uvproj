# Keil uVision project period_measure.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: period_measure +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\USER;.\INTER;.\DIGITAL
  group STARTUP
    ./: STARTUP.A51
  group USER
    ./user/: main.c
  group SYSTEM
    ./user/: system.c
    ./USER/: system.h
  group INTER
    ./inter/: interrupt.c interrupt.h
  group DIGITAL
    ./DIGITAL/: digital.c digital.h
