# Keil uVision project square_wave.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: square_wave +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\USER;.\TICKER
  group STARTUP
    ./: STARTUP.A51
  group SQUARE_WAVE
    ./TICKER/: square_wave.c
    ./ticker/: square_wave.h
  group USER
    ./USER/: main.c
  group SYSTEM
    ./USER/: system.c system.h
