# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\include
  group Source
    ./: STARTUP.A51 test.c
  group include
    $TC_ROOT$/../../Users/yuxia/Documents/MicroControllerInterface/1016/test1/include/: func.c func.h
