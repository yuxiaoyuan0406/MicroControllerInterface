# Keil uVision project interrupt_1.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: interrupt_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User;.\Inter
  group STARTUP
    ./: STARTUP.A51
  group USER
    ./USER/: main.c
    ./user/: system.c system.h
  group INTERUPT
    ./Inter/: interrupt.h
    ./inter/: interrupt.c
