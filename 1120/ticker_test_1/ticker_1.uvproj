# Keil uVision project ticker_1.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: ticker_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\USER;.\INTERRUPT
  group STARTUP
    ./startup/: STARTUP.A51
  group USER
    ./USER/: main.c
  group SYSTEM
    ./user/: system.c system.h
  group INT
    ./INTERRUPT/: inter.c inter.h
