# Keil uVision project Calculator.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: Calculator +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User;..\DigitalDisplay\Lib;.\lib
  group STARTUP
    ./: STARTUP.A51
  group USER
    ./USER/: main.c
    ./User/: system.h
    ./user/: system.c
  group DIGITAL
    ../DigitalDisplay/SRC/: digital.c
    ../DigitalDisplay/Lib/: digital.h
  group KEYBOARD
    ./lib/: keyboard.h
    ./src/: keyboard.c
