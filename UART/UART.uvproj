# Keil uVision project UART.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: UART +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ./user;./uart;./inter
  group STARTUP
    ./: STARTUP.A51
  group UART
    ./uart/: uart.c uart.h
  group USER
    ./user/: main.c
  group SYSTEM
    ./USER/: system.c system.h
  group INTER
    ./INTER/: interrupt.c interrupt.h
